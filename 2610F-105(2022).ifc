Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-05-30T14:20:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 30 14:20:16 2023 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\d1915630-a091-4da6-a74c-f0cddfb5b80f\a848e41c-2aea-456c-a050-91c5a4cd8b10\ifc * Database version: 5507 * Database creation date: Tue May 30 14:20:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 30 14:20:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 30 14:20:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 2610F-105 Washbasin faucet, 2610F-105(2022):2610F-105 Washbasin faucet:467319
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 146.2 mm; NominalHeight: 159.171 mm; NominalWidth: 46.4406 mm
Type - General - Author: BIMStone; BIMObjectName: 2610F-105(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - CO2 Emissions (A1-A3): 7.13; CO2 Emissions (A4): 0.2; CO2 Emissions (B7): 1297.8; CO2 Emissions (C2): 0.01; CO2 Emissions (C3): 0.01; CO2 Emissions (C4): 0.05; CO2 Emissions (D): -5.07; EAN Number: 6414150102387; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110409; Noise Class: I (ISO 3822); NRF Number: 4200327; RSK Number: 8275115; Sales Package dimensions (LxWxH): 540 x 146 x 59; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/2610F-105; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/181439_Oras Group EPD_Washbasin faucet.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/169261_2610F-105_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/2610F-105; VVS Number: 701576504
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2610F-105; 3D View: https://static.oras.com/AR/2610F-105; Catalog Drawing URL: http://static.oras.com/catdrw/2610F-105; Dimension Drawing URL: http://static.oras.com/dimdrw/2610F-105; FDV Document URL: http://www.oras.com/datasheet/2610F-105/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2610F-105; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/2610F-105; Interactive AR View URL: https://static.oras.com/AR/2610F-105; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2610F-105; Model: 2610F-105 Washbasin faucet; Name_en: 2610F-105 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2610F-105; Product Family: Oras Optima Eco; Product Image URL: http://static.oras.com/image/2610F-105; Product URL: http://static.oras.com/2610F-105; Spare-Part Information URL: http://static.oras.com/sp/2610F-105; Technical DataSheet URL: http://www.oras.com/datasheet/2610F-105/en; Type Name: 2610F-105 Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.00247203 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 109 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2610F-105(2022); Features: Single-lever; Finish: Polished; Grade: n/a; Material: brassPlastic; ModelNumber: n/a; ModelReference: 2610F-105; Name: 2610F-105 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 45x145x160 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 2610F-105 Washbasin faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2610F-105; Manufacturer: Oras
Pset_ProductRequirements - Name: 2610F-105 Washbasin faucet; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0385204 m2; Volume: 0.00108302 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2610F-105(2022): 2610F-105 Washbasin faucet; Family and Type: 2610F-105(2022): 2610F-105 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2610F-105(2022): 2610F-105 Washbasin faucet; Type Id: 2610F-105(2022): 2610F-105 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
